File: STBookDiagnosticTest/STBookDiagnosticTest.kicad_pcb (KiCad board)
At the start: 2 copper layers, 6 parts

Commit message: Minor fixes
Other:
- net class Default removed
